options:
  parameters:
    author: Michael Roe
    category: '[YSF2]'
    generate_options: hb
    id: c4fm_rx_vech
    output_language: python
    title: C4FM RX VECH
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '52'
    n: '72'
    offset: '20'
    type: complex
  states: {}
- name: c4fm_complex_to_interleaved_float_0
  id: c4fm_complex_to_interleaved_float
  parameters: {}
  states: {}
- name: c4fm_pad_missing_bb_1
  id: c4fm_pad_missing_bb
  parameters:
    length: '245'
    subframes: '45'
  states: {}
- name: c4fm_sign_scrambler_ff_0
  id: c4fm_sign_scrambler_ff
  parameters:
    count: '104'
    len: '8'
    mask: '0x11'
    seed: '0x1c9'
  states: {}
- name: c4fm_type_demux_cc_0
  id: c4fm_type_demux_cc
  parameters:
    data_type: '2'
    frame_type: '1'
    length: '360'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: '104'
    syms_per_block: '1'
    table: (0,4,8,12,16,20,24,28,32,36,40,44,48,52,56,60,64,68,72,76,80,84,88,92,96,100,1,5,9,13,17,21,25,29,33,37,41,45,49,53,57,61,65,69,73,77,81,85,89,93,97,101,2,6,10,14,18,22,26,30,34,38,42,46,50,54,58,62,66,70,74,78,82,86,90,94,98,102,3,7,11,15,19,23,27,31,35,39,43,47,51,55,59,63,67,71,75,79,83,87,91,95,99,103)
    type: float
  states: {}
- name: ysf2_vech_decode_fb_0
  id: ysf2_vech_decode_fb
  parameters: {}
  states: {}

connections:
- [blocks_keep_m_in_n_0, '0', c4fm_complex_to_interleaved_float_0, '0']
- [c4fm_complex_to_interleaved_float_0, '0', trellis_permutation_0, '0']
- [c4fm_pad_missing_bb_1, '0', pad_sink_0, '0']
- [c4fm_sign_scrambler_ff_0, '0', ysf2_vech_decode_fb_0, '0']
- [c4fm_type_demux_cc_0, '0', blocks_keep_m_in_n_0, '0']
- [pad_source_0, '0', c4fm_type_demux_cc_0, '0']
- [trellis_permutation_0, '0', c4fm_sign_scrambler_ff_0, '0']
- [ysf2_vech_decode_fb_0, '0', c4fm_pad_missing_bb_1, '0']

metadata:
  file_format: 1
