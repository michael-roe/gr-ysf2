<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>c4fm_rx_diversity</value></param>
<param><key>author</key><value>Michael Roe</value></param>
<param><key>category</key><value>[YSF2]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM RX Diversity</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsk_deviation_hz</value></param>
<param><key>value</key><value>900</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>samp_rate/(math.pi*fsk_deviation_hz)</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_1</value></param>
<param><key>gain</key><value>samp_rate/(math.pi*fsk_deviation_hz)</value></param>
</block>
<block>
<key>c4fm_maximal_ratio</key>
<param><key>id</key><value>c4fm_maximal_ratio_0</value></param>
<param><key>gain</key><value>1.0/0.767</value></param>
</block>
<block>
<key>c4fm_ratio_combiner_ff</key>
<param><key>id</key><value>c4fm_ratio_combiner_ff_0</value></param>
<param><key>angle</key><value>45</value></param>
</block>
<block>
<key>c4fm_rx_stage1_nofm</key>
<param><key>id</key><value>c4fm_rx_stage1_nofm_0</value></param>
</block>
<block>
<key>c4fm_rx_stage1_nofm</key>
<param><key>id</key><value>c4fm_rx_stage1_nofm_1</value></param>
</block>
<block>
<key>c4fm_rx_stage1_nofm</key>
<param><key>id</key><value>c4fm_rx_stage1_nofm_2</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_0</value></param>
<param><key>alpha</key><value>0.02</value></param>
<param><key>msg_nsamples</key><value>3600</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>digital_probe_mpsk_snr_est_c</key>
<param><key>id</key><value>digital_probe_mpsk_snr_est_c_1</value></param>
<param><key>alpha</key><value>0.02</value></param>
<param><key>msg_nsamples</key><value>3600</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_1</value></param>
<param><key>label</key><value>in1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>c4fm_ratio_combiner_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>c4fm_rx_stage1_nofm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>c4fm_ratio_combiner_ff_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_1</source_block_id><sink_block_id>c4fm_rx_stage1_nofm_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_maximal_ratio_0</source_block_id><sink_block_id>c4fm_ratio_combiner_ff_0</sink_block_id><source_key>out</source_key><sink_key>angle</sink_key></connection>
<connection><source_block_id>c4fm_ratio_combiner_ff_0</source_block_id><sink_block_id>c4fm_rx_stage1_nofm_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_nofm_0</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_nofm_1</source_block_id><sink_block_id>digital_probe_mpsk_snr_est_c_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_nofm_2</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_0</source_block_id><sink_block_id>c4fm_maximal_ratio_0</sink_block_id><source_key>snr</source_key><sink_key>in0</sink_key></connection>
<connection><source_block_id>digital_probe_mpsk_snr_est_c_1</source_block_id><sink_block_id>c4fm_maximal_ratio_0</sink_block_id><source_key>snr</source_key><sink_key>in1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_1</source_block_id><sink_block_id>analog_quadrature_demod_cf_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
