options:
  parameters:
    author: Michael Roe
    category: '[YSF2]'
    generate_options: hb
    id: c4fm_rx_tch
    output_language: python
    title: C4FM RX TCH
  states: {}

blocks:
- name: fsm
  id: variable
  parameters:
    value: gnuradio.trellis.fsm(1,2,[0b10011,0b11101])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '36'
    n: '72'
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: '176'
    n: '180'
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(2.0)
    type: complex
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,1,0,1,0,0,1,1,1,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0)
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: c4fm_crc16_decode_bb_0
  id: c4fm_crc16_decode_bb
  parameters:
    default_length: '176'
    error_tag: crc_error
    length_tag: packet_len
  states: {}
- name: c4fm_type_demux_cc_0
  id: c4fm_type_demux_cc
  parameters:
    data_type: '2'
    frame_type: '2'
    length: '360'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import gnuradio.trellis
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: '4'
    dim: '1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: (-1-1j,-1+1j,1-1j,1+1j)
    type: c
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: '180'
    syms_per_block: '1'
    table: (0,20,40,60,80,100,120,140,160,1,21,41,61,81,101,121,141,161,2,22,42,62,82,102,122,142,162,3,23,43,63,83,103,123,143,163,4,24,44,64,84,104,124,144,164,5,25,45,65,85,105,125,145,165,6,26,46,66,86,106,126,146,166,7,27,47,67,87,107,127,147,167,8,28,48,68,88,108,128,148,168,9,29,49,69,89,109,129,149,169,10,30,50,70,90,110,130,150,170,11,31,51,71,91,111,131,151,171,12,32,52,72,92,112,132,152,172,13,33,53,73,93,113,133,153,173,14,34,54,74,94,114,134,154,174,15,35,55,75,95,115,135,155,175,16,36,56,76,96,116,136,156,176,17,37,57,77,97,117,137,157,177,18,38,58,78,98,118,138,158,178,19,39,59,79,99,119,139,159,179)
    type: complex
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: '180'
    final_state: '0'
    fsm_args: fsm
    init_state: '0'
    type: b
  states: {}

connections:
- [blocks_keep_m_in_n_0, '0', trellis_permutation_0, '0']
- [blocks_keep_m_in_n_1, '0', c4fm_crc16_decode_bb_0, '0']
- [blocks_multiply_const_vxx_0, '0', trellis_metrics_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', pad_sink_0, '0']
- [blocks_vector_source_x_0, '0', blocks_xor_xx_0, '1']
- [blocks_xor_xx_0, '0', blocks_pack_k_bits_bb_0, '0']
- [c4fm_crc16_decode_bb_0, '0', blocks_xor_xx_0, '0']
- [c4fm_type_demux_cc_0, '0', blocks_keep_m_in_n_0, '0']
- [pad_source_0, '0', c4fm_type_demux_cc_0, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0, '0']
- [trellis_permutation_0, '0', blocks_multiply_const_vxx_0, '0']
- [trellis_viterbi_x_0, '0', blocks_keep_m_in_n_1, '0']

metadata:
  file_format: 1
