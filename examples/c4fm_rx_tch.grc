<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>c4fm_rx_tch</value></param>
<param><key>author</key><value>Michael Roe</value></param>
<param><key>category</key><value>[YSF2]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>C4FM RX TCH</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fsm</value></param>
<param><key>value</key><value>gnuradio.trellis.fsm(1,2,[0b10011,0b11101])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>36</value></param>
<param><key>n</key><value>72</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_1</value></param>
<param><key>m</key><value>176</value></param>
<param><key>n</key><value>180</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>math.sqrt(2.0)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>(1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1,0,1,1,1,0,0,1,1,0,0,1,0,0,0,0,0,1,0,0,1,0,1,0,0,1,1,1,0,1,1,0,1,0,0,0,1,1,1,1,0,0,1,1,1,1,1,0,0,1,1,0,1,1,0,0,0)</value></param>
</block>
<block>
<key>blocks_xor_xx</key>
<param><key>id</key><value>blocks_xor_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>c4fm_crc16_bb</key>
<param><key>id</key><value>c4fm_crc16_bb_0</value></param>
<param><key>check</key><value>1</value></param>
<param><key>length</key><value>160</value></param>
</block>
<block>
<key>c4fm_type_demux_cc</key>
<param><key>id</key><value>c4fm_type_demux_cc_0</value></param>
<param><key>data_type</key><value>2</value></param>
<param><key>frame_type</key><value>2</value></param>
<param><key>length</key><value>360</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>import gnuradio.trellis</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>trellis_metrics_x</key>
<param><key>id</key><value>trellis_metrics_x_0</value></param>
<param><key>table</key><value>-1-1j,-1+1j,1-1j,1+1j</value></param>
<param><key>dim</key><value>1</value></param>
<param><key>metric_type</key><value>digital.TRELLIS_EUCLIDEAN</value></param>
<param><key>card</key><value>4</value></param>
<param><key>type</key><value>c</value></param>
</block>
<block>
<key>trellis_permutation</key>
<param><key>id</key><value>trellis_permutation_0</value></param>
<param><key>interleaver_size</key><value>180</value></param>
<param><key>syms_per_block</key><value>1</value></param>
<param><key>table</key><value>0,20,40,60,80,100,120,140,160,1,21,41,61,81,101,121,141,161,2,22,42,62,82,102,122,142,162,3,23,43,63,83,103,123,143,163,4,24,44,64,84,104,124,144,164,5,25,45,65,85,105,125,145,165,6,26,46,66,86,106,126,146,166,7,27,47,67,87,107,127,147,167,8,28,48,68,88,108,128,148,168,9,29,49,69,89,109,129,149,169,10,30,50,70,90,110,130,150,170,11,31,51,71,91,111,131,151,171,12,32,52,72,92,112,132,152,172,13,33,53,73,93,113,133,153,173,14,34,54,74,94,114,134,154,174,15,35,55,75,95,115,135,155,175,16,36,56,76,96,116,136,156,176,17,37,57,77,97,117,137,157,177,18,38,58,78,98,118,138,158,178,19,39,59,79,99,119,139,159,179</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>trellis_viterbi_x</key>
<param><key>id</key><value>trellis_viterbi_x_0</value></param>
<param><key>block_size</key><value>180</value></param>
<param><key>fsm_args</key><value>fsm</value></param>
<param><key>final_state</key><value>0</value></param>
<param><key>init_state</key><value>0</value></param>
<param><key>type</key><value>b</value></param>
</block>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>trellis_permutation_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1</source_block_id><sink_block_id>c4fm_crc16_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>trellis_metrics_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_xor_xx_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_crc16_bb_0</source_block_id><sink_block_id>blocks_xor_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_type_demux_cc_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>c4fm_type_demux_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_metrics_x_0</source_block_id><sink_block_id>trellis_viterbi_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_permutation_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>trellis_viterbi_x_0</source_block_id><sink_block_id>blocks_keep_m_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
