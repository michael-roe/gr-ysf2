options:
  parameters:
    author: Michael Roe
    category: '[YSF2]'
    generate_options: hb
    id: c4fm_tx
    output_language: python
    title: C4FM TX
  states: {}

blocks:
- name: fsm
  id: variable
  parameters:
    value: gnuradio.trellis.fsm(1,2,[0b10011,0b11101])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 3.1459*900/samp_rate
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (96, 4)
    type: byte
  states: {}
- name: blocks_stream_mux_1
  id: blocks_stream_mux
  parameters:
    lengths: (20,52)
    type: byte
  states: {}
- name: blocks_stream_mux_2
  id: blocks_stream_mux
  parameters:
    lengths: (20,100,360)
    num_inputs: '3'
    type: byte
  states: {}
- name: blocks_stream_mux_3
  id: blocks_stream_mux
  parameters:
    lengths: (96,4)
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,0,1,1,1,1,1,0,0,0,1)
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,1,0,1,0,1,0,0,0,1,1,1,0,0,0,1,1,1,0,0,1,0,0,1,0,1,1,0,0,0,1,1,0,1,0,0,1,1,0,1)
  states: {}
- name: blocks_vector_source_x_3
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,0,1,0,0,1,1,1,1,0,1,0,1,1,1,0,1,0,1,0,0,0,1,0,0,1,0,0,0,0,1,1,0,0,1,1,1,0,0,0,0,1,0,1,1,1,1,0,1,1,0,1,1,0,0,1,1,0,1,0,0,0,0,1,1,1,0,1,1,1,1,0,0,0,0,1,1,1,1)
  states: {}
- name: blocks_vector_source_x_4
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0)
  states: {}
- name: blocks_xor_xx_0
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: blocks_xor_xx_1
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: c4fm_crc16_encode_bb_0
  id: c4fm_crc16_encode_bb
  parameters:
    default_length: '32'
    length_tag: packet_len
  states: {}
- name: c4fm_crc16_encode_bb_1
  id: c4fm_crc16_encode_bb
  parameters:
    default_length: '80'
    length_tag: packet_len
  states: {}
- name: c4fm_golay_encoder_bb_0
  id: c4fm_golay_encoder_bb
  parameters: {}
  states: {}
- name: callsign
  id: parameter
  parameters:
    label: Callsign
    short_id: callsign
    type: str
    value: '""'
  states: {}
- name: digital_chunks_to_symbols_xx_1
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (1,3,-1,-3)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.trellis
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '10'
    gain: '10'
    interp: '10'
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: '4800'
    type: interp_fir_filter_fff
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: fsm
    init_state: '0'
    type: bb
  states: {}
- name: trellis_encoder_xx_1
  id: trellis_encoder_xx
  parameters:
    fsm_args: fsm
    init_state: '0'
    type: bb
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: '100'
    syms_per_block: '1'
    table: (0,5,10,15,20,25,30,35,40,45,50,55,60,65,70,75,80,85,90,95,1,6,11,16,21,26,31,36,41,46,51,56,61,66,71,76,81,86,91,96,2,7,12,17,22,27,32,37,42,47,52,57,62,67,72,77,82,87,92,97,3,8,13,18,23,28,33,38,43,48,53,58,63,68,73,78,83,88,93,98,4,9,14,19,24,29,34,39,44,49,54,59,64,69,74,79,84,89,94,99)
    type: byte
  states: {}
- name: trellis_permutation_1
  id: trellis_permutation
  parameters:
    interleaver_size: '104'
    syms_per_block: '1'
    table: (0,26,52,78,1,27,53,79,2,28,54,80,3,29,55,81,4,30,56,82,5,31,57,83,6,32,58,84,7,33,59,85,8,34,60,86,9,35,61,87,10,36,62,88,11,37,63,89,12,38,64,90,13,39,65,91,14,40,66,92,15,41,67,93,16,42,68,94,17,43,69,95,18,44,70,96,19,45,71,97,20,46,72,98,21,47,73,99,22,48,74,100,23,49,75,101,24,50,76,102,25,51,77,103)
    type: byte
  states: {}
- name: trellis_permutation_2
  id: trellis_permutation
  parameters:
    interleaver_size: '100'
    syms_per_block: '1'
    table: (0,5,10,15,20,25,30,35,40,45,50,55,60,65,70,75,80,85,90,95,1,6,11,16,21,26,31,36,41,46,51,56,61,66,71,76,81,86,91,96,2,7,12,17,22,27,32,37,42,47,52,57,62,67,72,77,82,87,92,97,3,8,13,18,23,28,33,38,43,48,53,58,63,68,73,78,83,88,93,98,4,9,14,19,24,29,34,39,44,49,54,59,64,69,74,79,84,89,94,99)
    type: byte
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mux
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mux
  states: {}
- name: ysf2_dch_source_b_0
  id: ysf2_dch_source_b
  parameters:
    callsign: callsign
  states: {}
- name: ysf2_fich_source_b_0
  id: ysf2_fich_source_b
  parameters:
    data_type: '2'
    narrowband: '1'
    squelch: '0'
  states: {}
- name: ysf2_vech_encode_bb_0
  id: ysf2_vech_encode_bb
  parameters: {}
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', pad_sink_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_mux_1, '1']
- [blocks_pack_k_bits_bb_1, '0', blocks_stream_mux_2, '0']
- [blocks_stream_mux_0, '0', trellis_encoder_xx_0, '0']
- [blocks_stream_mux_1, '0', blocks_stream_mux_2, '2']
- [blocks_stream_mux_2, '0', virtual_sink_0, '0']
- [blocks_stream_mux_3, '0', trellis_encoder_xx_1, '0']
- [blocks_unpack_k_bits_bb_2, '0', blocks_xor_xx_1, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_1, '0', blocks_xor_xx_0, '0']
- [blocks_vector_source_x_2, '0', blocks_pack_k_bits_bb_1, '0']
- [blocks_vector_source_x_3, '0', blocks_xor_xx_1, '1']
- [blocks_vector_source_x_4, '0', blocks_stream_mux_3, '1']
- [blocks_xor_xx_0, '0', trellis_permutation_1, '0']
- [blocks_xor_xx_1, '0', c4fm_crc16_encode_bb_1, '0']
- [c4fm_crc16_encode_bb_0, '0', c4fm_golay_encoder_bb_0, '0']
- [c4fm_crc16_encode_bb_1, '0', blocks_stream_mux_3, '0']
- [c4fm_golay_encoder_bb_0, '0', blocks_stream_mux_0, '0']
- [digital_chunks_to_symbols_xx_1, '0', root_raised_cosine_filter_0, '0']
- [pad_source_0, '0', ysf2_vech_encode_bb_0, '0']
- [root_raised_cosine_filter_0, '0', analog_frequency_modulator_fc_0, '0']
- [trellis_encoder_xx_0, '0', trellis_permutation_0, '0']
- [trellis_encoder_xx_1, '0', trellis_permutation_2, '0']
- [trellis_permutation_0, '0', blocks_stream_mux_2, '1']
- [trellis_permutation_1, '0', blocks_pack_k_bits_bb_0, '0']
- [trellis_permutation_2, '0', blocks_stream_mux_1, '0']
- [virtual_source_0, '0', digital_chunks_to_symbols_xx_1, '0']
- [ysf2_dch_source_b_0, '0', blocks_unpack_k_bits_bb_2, '0']
- [ysf2_fich_source_b_0, '0', c4fm_crc16_encode_bb_0, '0']
- [ysf2_vech_encode_bb_0, '0', blocks_xor_xx_0, '1']

metadata:
  file_format: 1
