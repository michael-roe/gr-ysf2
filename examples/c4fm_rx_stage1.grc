options:
  parameters:
    author: Nichael Roe
    category: '[YSF2]'
    generate_options: hb
    id: c4fm_rx_stage1
    output_language: python
    title: C4FM RX Stage 1
  states: {}

blocks:
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '900'
  states: {}
- name: fsm_stage1
  id: variable
  parameters:
    value: gnuradio.trellis.fsm(1,2,[0b10011,0b11101])
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(math.pi*fsk_deviation_hz)
  states: {}
- name: blocks_keep_m_in_n_0
  id: blocks_keep_m_in_n
  parameters:
    m: '96'
    n: '100'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_1
  id: blocks_keep_m_in_n
  parameters:
    m: '12'
    n: '24'
    offset: '0'
    type: byte
  states: {}
- name: blocks_keep_m_in_n_2
  id: blocks_keep_m_in_n
  parameters:
    m: '32'
    n: '48'
    offset: '0'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.sqrt(2.0)
    type: complex
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"burst_length"'
    type: byte
  states: {state: disabled}
- name: c4fm_c4fm_soft_decision_fc_0
  id: c4fm_c4fm_soft_decision_fc
  parameters:
    gain: math.sqrt(0.5)
  states: {}
- name: c4fm_correlate_access_code_tag_cc_0
  id: c4fm_correlate_access_code_tag_cc
  parameters:
    length: '480'
    sync: '0xd471c9634d '
    sync_len: '40'
    threshold: '20'
    threshold2: '16'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: '10'
    omega_relative_limit: '0.001'
    type: complex
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: '100'
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload_len"'
    output_symbols: 'True'
    samp_rate: '4800'
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"correlation"'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import gnuradio.trellis
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: '4800'
    type: fir_filter_fff
  states: {}
- name: trellis_metrics_x_0
  id: trellis_metrics_x
  parameters:
    card: '4'
    dim: '1'
    metric_type: digital.TRELLIS_EUCLIDEAN
    table: (-1-1j,-1+1j,1-1j,1+1j)
    type: c
  states: {}
- name: trellis_permutation_0
  id: trellis_permutation
  parameters:
    interleaver_size: '100'
    syms_per_block: '1'
    table: (0,20,40,60,80,1,21,41,61,81,2,22,42,62,82,3,23,43,63,83,4,24,44,64,84,5,25,45,65,85,6,26,46,66,86,7,27,47,67,87,8,28,48,68,88,9,29,49,69,89,10,30,50,70,90,11,31,51,71,91,12,32,52,72,92,13,33,53,73,93,14,34,54,74,94,15,35,55,75,95,16,36,56,76,96,17,37,57,77,97,18,38,58,78,98,19,39,59,79,99)
    type: complex
  states: {}
- name: trellis_viterbi_x_0
  id: trellis_viterbi_x
  parameters:
    block_size: '100'
    final_state: '0'
    fsm_args: fsm_stage1
    init_state: '0'
    type: b
  states: {}
- name: ysf2_fich_parser_b_0
  id: ysf2_fich_parser_b
  parameters: {}
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_keep_m_in_n_0, '0', blocks_keep_m_in_n_1, '0']
- [blocks_keep_m_in_n_1, '0', blocks_keep_m_in_n_2, '0']
- [blocks_keep_m_in_n_2, '0', ysf2_fich_parser_b_0, '0']
- [blocks_multiply_const_vxx_1, '0', trellis_metrics_x_0, '0']
- [c4fm_c4fm_soft_decision_fc_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [c4fm_correlate_access_code_tag_cc_0, '0', digital_header_payload_demux_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', c4fm_correlate_access_code_tag_cc_0, '0']
- [digital_header_payload_demux_0, '0', trellis_permutation_0, '0']
- [digital_header_payload_demux_0, '1', pad_sink_0, '0']
- [pad_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [root_raised_cosine_filter_0, '0', c4fm_c4fm_soft_decision_fc_0, '0']
- [trellis_metrics_x_0, '0', trellis_viterbi_x_0, '0']
- [trellis_permutation_0, '0', blocks_multiply_const_vxx_1, '0']
- [trellis_viterbi_x_0, '0', blocks_keep_m_in_n_0, '0']
- [ysf2_fich_parser_b_0, header_data, digital_header_payload_demux_0, header_data]

metadata:
  file_format: 1
