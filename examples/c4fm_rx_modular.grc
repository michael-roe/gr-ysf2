<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_low_pass_filter_taps</key>
<param><key>id</key><value>my_filter</value></param>
<param><key>cutoff_freq</key><value>9000</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>100</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>c4fm-48k.wav</value></param>
<param><key>type</key><value>short</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_interleaved_short_to_complex</key>
<param><key>id</key><value>blocks_interleaved_short_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>20</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>filter</key><value>"frame_number"</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>c4fm_rx_dch</key>
<param><key>id</key><value>c4fm_rx_dch_0</value></param>
</block>
<block>
<key>c4fm_rx_stage1</key>
<param><key>id</key><value>c4fm_rx_stage1_0</value></param>
</block>
<block>
<key>c4fm_rx_tch</key>
<param><key>id</key><value>c4fm_rx_tch_0</value></param>
</block>
<block>
<key>c4fm_rx_vech</key>
<param><key>id</key><value>c4fm_rx_vech_0</value></param>
</block>
<block>
<key>c4fm_tag_to_message_c</key>
<param><key>id</key><value>c4fm_tag_to_message_c_0</value></param>
<param><key>key</key><value>snr</value></param>
</block>
<block>
<key>digital_mpsk_snr_est_cc</key>
<param><key>id</key><value>digital_mpsk_snr_est_cc_0</value></param>
<param><key>alpha</key><value>0.001</value></param>
<param><key>tag_nsamples</key><value>3600</value></param>
<param><key>type</key><value>0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>12500</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>my_filter</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_0</value></param>
<param><key>key</key><value>callsign</value></param>
<param><key>label</key><value>Callsign</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_1</value></param>
<param><key>key</key><value>hwid</value></param>
<param><key>label</key><value>hardware id</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_2</value></param>
<param><key>key</key><value>snr</value></param>
<param><key>label</key><value>snr</value></param>
<param><key>type</key><value>double</value></param>
</block>
<block>
<key>qtgui_edit_box_msg</key>
<param><key>id</key><value>qtgui_edit_box_msg_3</value></param>
<param><key>key</key><value>location</value></param>
<param><key>label</key><value>location</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>ysf2_dch_parser_b</key>
<param><key>id</key><value>ysf2_dch_parser_b_0</value></param>
</block>
<block>
<key>ysf2_vocoder_dummy_bf</key>
<param><key>id</key><value>ysf2_vocoder_dummy_bf_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_interleaved_short_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_short_to_complex_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_dch_0</source_block_id><sink_block_id>ysf2_dch_parser_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_0</source_block_id><sink_block_id>c4fm_rx_dch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_0</source_block_id><sink_block_id>c4fm_rx_tch_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_0</source_block_id><sink_block_id>c4fm_rx_vech_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_stage1_0</source_block_id><sink_block_id>digital_mpsk_snr_est_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_tch_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_vech_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_vech_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_rx_vech_0</source_block_id><sink_block_id>ysf2_vocoder_dummy_bf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>c4fm_tag_to_message_c_0</source_block_id><sink_block_id>qtgui_edit_box_msg_2</sink_block_id><source_key>out</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>digital_mpsk_snr_est_cc_0</source_block_id><sink_block_id>c4fm_tag_to_message_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>c4fm_rx_stage1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ysf2_dch_parser_b_0</source_block_id><sink_block_id>qtgui_edit_box_msg_0</sink_block_id><source_key>callsign_data</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>ysf2_dch_parser_b_0</source_block_id><sink_block_id>qtgui_edit_box_msg_1</sink_block_id><source_key>hwid</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>ysf2_dch_parser_b_0</source_block_id><sink_block_id>qtgui_edit_box_msg_3</sink_block_id><source_key>location</source_key><sink_key>val</sink_key></connection>
<connection><source_block_id>ysf2_vocoder_dummy_bf_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
